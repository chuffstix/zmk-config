## boards/shields/keebformom/Kconfig.defconfig
```kconfig
if SHIELD_KEEBFORMOM

config ZMK_KEYBOARD_NAME
    default "KFM Macropad"

endif
```
